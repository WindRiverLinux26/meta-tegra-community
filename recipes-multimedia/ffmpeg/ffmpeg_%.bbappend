BBCLASSEXTEND = "native"
PACKAGECONFIG:class-native = "avcodec avfilter avformat swscale"
